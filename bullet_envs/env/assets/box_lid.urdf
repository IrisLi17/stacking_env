Commit message: add a tennis ball to the environment

File: bullet_envs/env/assets/box_lid.urdf (robot description, URDF)
Before this commit: robot box_lid.urdf, 6 links, 5 joints
Links:
- link lid: mass .0212 -> 0.027; geometry collision box size=0.03 0.03 0.05; visual box size=0.03 0.03 0.05
